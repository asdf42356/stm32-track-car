# Keil uVision project 1.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: K题
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .;D:\cunfang\keil\ARM\PACK\ARM\CMSIS\5.0.1\CMSIS\Include;D:\cunfang\keil\ARM\PACK\Keil\STM32F1xx_DFP\2.2.0\Device\StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c mpu6050.c mpu6050.h stm32f10x_conf.h motor.c motor.h encoder.c encoder.h
    D:/cunfang/keil/ARM/PACK/Keil/STM32F1xx_DFP/2.2.0/Device/Source/: system_stm32f10x.c
    D:/cunfang/keil/ARM/PACK/Keil/STM32F1xx_DFP/2.2.0/Device/Source/ARM/: startup_stm32f10x_md.s
    D:/cunfang/keil/ARM/PACK/Keil/STM32F1xx_DFP/2.2.0/Device/StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_tim.c misc.c
